# Keil uVision project AutoAITalk.uvprojx, settings and files
target AutoAITalk (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32H482RE Nationstech
  pack: Nationstech.N32H48x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AutoAITalk +hex
  AfterMake: fromelf --bin --output=.\Objects\test.bin .\Objects\test.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32H482, USE_STDPERIPH_DRIVER, USE_ALLOCA=1
  c include: .\user\inc;.\firmware\CMSIS\core;.\firmware\CMSIS\device;.\firmware\n32h47x_48x_std_periph_driver\inc;.\bsp\inc;.\ws2812;.\microphone;.\opus_tool\celt;.\opus_tool\include;.\opus_tool\silk;.\opus_tool\silk\arm;.\opus_tool\silk\fixed;.\opus_tool\silk\fixed\arm;.\opus_tool\silk\fixed\mips;.\opus_tool\silk\float;.\opus_tool\silk\mips;.\opus_tool\silk\x86;.\opus_tool\src;.\opus_tool\dnn;.\opus_tool\dnn\arm;.\opus_tool\dnn\x86;.\opus_tool\celt\arm;.\opus_tool\celt\mips;.\opus_tool\celt\x86;.\speaker;.\websocket;.\hw-config;.\firmware\n32h47x_48x_usbfsd_driver\inc;.\Queue
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group startup
    ./firmware/CMSIS/device/startup/: startup_n32h482.s
  group cmsis
    ./firmware/CMSIS/device/: system_n32h47x_48x.c
  group fwlb
    ./firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_adc.c n32h47x_48x_comp.c n32h47x_48x_cordic.c n32h47x_48x_crc.c n32h47x_48x_dac.c n32h47x_48x_dbg.c n32h47x_48x_dma.c n32h47x_48x_dvp.c n32h47x_48x_eth.c n32h47x_48x_pwr.c n32h47x_48x_exti.c n32h47x_48x_fdcan.c n32h47x_48x_femc.c n32h47x_48x_flash.c n32h47x_48x_fmac.c n32h47x_48x_gpio.c n32h47x_48x_i2c.c n32h47x_48x_iwdg.c n32h47x_48x_lptim.c n32h47x_48x_pga.c n32h47x_48x_rcc.c n32h47x_48x_rtc.c n32h47x_48x_sdio.c n32h47x_48x_shrtim.c n32h47x_48x_spi.c n32h47x_48x_tim.c n32h47x_48x_usart.c n32h47x_48x_vrefbuf.c n32h47x_48x_wwdg.c n32h47x_48x_xspi.c
  group user
    ./user/src/: main.c n32h47x_48x_it.c
  group bsp
    ./bsp/src/: delay.c log.c
  group WS2812
    ./ws2812/: ws2812.c ws2812.h
  group microphone
    ./microphone/: microphone.c microphone.h
  group opus_src
    ./opus_tool/src/: analysis.c extensions.c mapping_matrix.c mlp.c mlp_data.c opus.c opus_decoder.c opus_encoder.c opus_multistream.c opus_multistream_decoder.c opus_multistream_encoder.c opus_projection_decoder.c opus_projection_encoder.c repacketizer.c
  group opus_celt
    ./opus_tool/celt/: bands.c celt.c celt_decoder.c celt_encoder.c celt_lpc.c cwrs.c entcode.c entdec.c entenc.c kiss_fft.c laplace.c mathops.c mdct.c modes.c pitch.c quant_bands.c rate.c vq.c
  group opus_silk
    ./opus_tool/silk/: dec_API.c enc_API.c table_LSF_cos.c tables_gain.c tables_LTP.c tables_NLSF_CB_NB_MB.c tables_NLSF_CB_WB.c tables_other.c tables_pitch_lag.c tables_pulses_per_block.c A2NLSF.c ana_filt_bank_1.c biquad_alt.c bwexpander.c bwexpander_32.c check_control_input.c CNG.c code_signs.c control_audio_bandwidth.c control_SNR.c debug.c decode_core.c decode_frame.c decode_indices.c decode_parameters.c decode_pitch.c decode_pulses.c encode_indices.c decoder_set_fs.c encode_pulses.c gain_quant.c HP_variable_cutoff.c init_decoder.c init_encoder.c inner_prod_aligned.c interpolate.c lin2log.c log2lin.c LP_variable_cutoff.c LPC_analysis_filter.c LPC_fit.c LPC_inv_pred_gain.c NLSF_decode.c NLSF_del_dec_quant.c NLSF_encode.c NLSF_stabilize.c NLSF_unpack.c NLSF_VQ.c NLSF_VQ_weights_laroia.c NLSF2A.c NSQ.c NSQ_del_dec.c pitch_est_tables.c PLC.c process_NLSFs.c quant_LTP_gains.c resampler.c resampler_down2.c resampler_down2_3.c resampler_private_AR2.c resampler_private_down_FIR.c resampler_private_IIR_FIR.c resampler_private_up2_HQ.c resampler_rom.c shell_coder.c sigm_Q15.c sort.c stereo_decode_pred.c stereo_encode_pred.c stereo_find_predictor.c stereo_LR_to_MS.c stereo_MS_to_LR.c stereo_quant_pred.c sum_sqr_shift.c VAD.c VQ_WMat_EC.c control_codec.c
  group opus_silk_flp
    ./opus_tool/silk/float/: apply_sine_window_FLP.c autocorrelation_FLP.c burg_modified_FLP.c bwexpander_FLP.c corrMatrix_FLP.c encode_frame_FLP.c energy_FLP.c find_LPC_FLP.c find_LTP_FLP.c find_pitch_lags_FLP.c find_pred_coefs_FLP.c inner_product_FLP.c k2a_FLP.c LPC_analysis_filter_FLP.c LPC_inv_pred_gain_FLP.c LTP_analysis_filter_FLP.c LTP_scale_ctrl_FLP.c noise_shape_analysis_FLP.c pitch_analysis_core_FLP.c process_gains_FLP.c regularize_correlations_FLP.c residual_energy_FLP.c scale_copy_vector_FLP.c scale_vector_FLP.c schur_FLP.c sort_FLP.c warped_autocorrelation_FLP.c wrappers_FLP.c
  group speaker
    ./speaker/: speaker.c speaker.h
  group websocket
    ./websocket/: websocket.c websocket.h
  group hw_config
    ./hw-config/: hw_config.c hw_config.h usbfsd_conf.h usbfsd_desc.c usbfsd_desc.h usbfsd_endp.c usbfsd_istr.c usbfsd_istr.h usbfsd_prop.c usbfsd_prop.h usbfsd_pwr.c usbfsd_pwr.h
  group n32h47x_48x_usbfsd_driver
    ./firmware/n32h47x_48x_usbfsd_driver/src/: usbfsd_core.c usbfsd_init.c usbfsd_int.c usbfsd_mem.c usbfsd_regs.c usbfsd_sil.c
  group Queue
    ./Queue/: queue.c queue.h
